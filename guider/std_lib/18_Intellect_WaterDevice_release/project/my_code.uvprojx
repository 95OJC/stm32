# Keil uVision project my_code.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: my_code +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\lib\stm32f10x_periph_driver;..\lib\stm32f10x_periph_driver\inc;..\user\app\inc;..\user\bios\inc;..\lib\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../lib/CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group lib
    ../lib/stm32f10x_periph_driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group bios
    ../user/bios/src/: stm32f10x_it.c hardinit.c gpio.c keyCtrl.c systick_rcc.c timer.c usart.c ringbuf.c if.c shell.c dma.c iic.c AT24C02eeprom.c spi.c W25Q64flash.c adda.c bios.c keyTTP224.c WaterSensor.c DCmotor.c heater.c DS18B20.c OLED096.c
  group app
    ../user/app/src/: main.c monitor.c sysRam.c
